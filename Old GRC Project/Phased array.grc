options:
  parameters:
    generate_options: qt_gui
    id: PATest
    output_language: python
    title: Phased array processing
  states: {}

blocks:
- name: a0delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: a1delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: a2delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: a3delay
  id: variable
  parameters:
    value: '0'
  states: {}
- name: angle
  id: variable_struct
  parameters:
    field0: x
    field1: y
    value0: '0'
    value1: '0'
  states: {}
- name: ant_freq
  id: variable
  parameters:
    value: 1420.4057517667M
  states: {}
- name: c
  id: variable
  parameters:
    value: 299800k
  states: {}
- name: delay
  id: variable_struct
  parameters:
    field0: array0
    field1: array1
    field2: array2
    field3: array3
    value0: '0'
    value1: '0'
    value2: '0'
    value3: '0'
  states: {}
- name: local_freq
  id: variable
  parameters:
    value: 70M
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48k
  states: {}
- name: t
  id: variable
  parameters:
    value: array0.delay
  states: {}
- name: wlen
  id: variable
  parameters:
    value: c / ant_freq
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '4'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: a0delay
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: a1delay
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: a3delay
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: a2delay
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: 1,1,1,1
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_wavfile_source_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0_0_1
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0_0_0_2
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: probe_strength
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import numpy as np
      sky = np.arrange(1000000).reshape(1000,1000)
      x = 0, y = 0, elements = 4
      while y < 1000:
          while x < 1000:
              sky([x][y]) = probe_strength
    priority: ''
    section: main_after_init
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_0_0, '0']
- [audio_source_0, '2', blocks_multiply_const_vxx_0_1, '0']
- [audio_source_0, '3', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_delay_2, '0']
- [blocks_add_xx_0_0_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0_0_1, '0', blocks_delay_1, '0']
- [blocks_add_xx_0_0_2, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_delay_1, '0', blocks_stream_mux_0_0, '1']
- [blocks_delay_2, '0', blocks_stream_mux_0_0, '3']
- [blocks_delay_3, '0', blocks_stream_mux_0_0, '2']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0_1, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_0_0_2, '1']
- [blocks_stream_mux_0_0, '0', probe_strength, '0']
- [blocks_wavfile_source_0_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_wavfile_source_0_0_0_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_wavfile_source_0_0_0_0_1, '0', blocks_add_xx_0_0_1, '0']
- [blocks_wavfile_source_0_0_0_0_2, '0', blocks_add_xx_0_0_2, '0']

metadata:
  file_format: 1
